# Keil uVision project project.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\CMSIS\Include;..\ek-tm4c123gxl
  asm define: Stack_Size=2048,Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c traffic_light.c
  group inc
    ./: traffic_light.h
    ../ek-tm4c123gxl/: TM4C123GH6PM.h
  group doc
    ./: project_structure.txt
software components: Device:Startup 1.0.1
